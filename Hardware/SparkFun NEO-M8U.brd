# Repository sparkfun/SparkFun_u-blox_NEO-M8U

File README.md:

SparkFun GPS Dead Reckoning Breakout - NEO-M8U (Qwiic)
========================================

[SparkFun GPS Dead Reckoning Breakout - NEO-M8U (Qwiic) [GPS-16329]](https://www.sparkfun.com/products/16329)

The SparkFun NEO-M8U GPS Breakout is a high quality, GPS board with equally impressive configuration options. The NEO-M8U takes advantage of u-blox's Untethered Dead Reckoning (UDR) technology. The module provides continuous navigation without needing to make any electrical connection to a vehicle, thus reducing cost of installation for after-market dead reckoning applications. 

The NEO-M8U module is a 72-channel u-blox M8 engine GNSS receiver, meaning it can receive signals from the GPS, GLONASS, Galileo, and BeiDou constellations with ~2.5 meter accuracy. The module supports concurrent reception of three GNSS systems. The combination of GNSS and integrated 3D sensor measurements on the NEO-M8U provide accurate, real-time positioning rates of up to 30Hz. 

Compared to other GPS modules, this breakout maximizes position accuracy in dense cities or covered areas. Even under poor signal conditions, continuous positioning is provided in urban environments and is also available during complete signal loss (e.g. short tunnels and parking garages). With UDR, position begins as soon as power is applied to the board even before the first GNSS fix is available! Lock time is further reduced with on-board rechargeable battery; you'll have backup power enabling the GPS to get a hot lock within seconds!

Additionally, this u-blox receiver supports I<sup>2</sup>C (u-blox calls this Display Data Channel) which made it perfect for the Qwiic compatibility so we don't have to use up our precious UART ports. Utilizing our handy Qwiic system, no soldering is required to connect it to the rest of your system. However, we still have broken out 0.1"-spaced pins in case you prefer to use a breadboard. 

U-blox based GPS products are configurable using the popular, but dense, windows program called u-center. Plenty of different functions can be configured on the NEO-M8U: baud rates, update rates, geofencing, spoofing detection, external interrupts, SBAS/D-GPS, etc. All of this can be done within the SparkFun Arduino Library!

The SparkFun NEO-M8U GPS Breakout is also equipped with an on-board rechargeable battery that provides power to the RTC on the NEO-M8U.  This reduces the time-to-first fix from a cold start (~26s) to a hot start (~1.5s). The battery will maintain RTC and GNSS orbit data without being connected to power for plenty of time.

Repository Contents
-------------------

* **/Documentation** - Data sheets for the NEO-M8U
* **/Hardware** - Eagle design files (.brd, .sch)
* **/Production** - Production panel files (.brd)

Documentation
--------------
* **[Library](https://github.com/sparkfun/SparkFun_u-blox_GNSS_Arduino_Library)** - Arduino Library the SparkFun GPS ublox products.
* **[Hookup Guide](https://learn.sparkfun.com/tutorials/1166)** - Basic hookup guide for the SparkFun GPS NEO-M8U

License Information
-------------------

This product is _**open source**_! 

Please review the LICENSE.md file for license information. 

If you have any questions or concerns on licensing, please contact technical support on our [SparkFun forums](https://forum.sparkfun.com/viewforum.php?f=152).

Distributed as-is; no warranty is given.

- Your friends at SparkFun.

## EAGLE design Hardware/SparkFun NEO-M8U.brd

Parts:
BT1: 6.8MM_COIN_CELL; ML414H_IV01E
C1, C2, C4: 1.0uF; 0603
C3: 47pF; 0603
C5: 0.1uF; 0603
D1: RED; LED-0603
D2: BLUE; LED-0603
D3: 0.5A/40V/420mV; SOD-323
D4: PRTR5V0U2F; SOT886
FB1: 30Ω/1.8A; 0603
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1, J2: CONN_041X04_NO_SILK; 1X04_NO_SILK
J3, J4: Qwiic Right Angle; JST04_1MM_RA
J5: USB_C_2-LAYER_PADS; USB-C-16P-2LAYER-PADS
J6: CONN_07NO_SILK; 1X07_NO_SILK
J7: U.FL
JP1: JUMPER-SMT_3_2-NC_TRACE_SILK; SMT-JUMPER_3_2-NC_TRACE_SILK
JP2, JP3: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
JP4: JUMPER-SMT_2_NO_SILK; SMT-JUMPER_2_NO_SILK
JP5, JP6, JP7, JP8: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
JP9, JP10, JP11, JP12: STAND-OFF
LOGO1: OSHW-LOGOMINI; OSHW-LOGO-MINI
LOGO2: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
R1, R2: 27; 0603
R3: 100k; 0603
R4, R7: 2.2k; 0603
R5, R6, R14: 1k; 0603
R8, R9, R10, R11: 33; 0603
R12, R13: 5.1k; 0603
R15: 10; 0603
U1: U-BLOX_MEO-M8U; NEO-M9N/M8T/M8U
U2: 3.3V; SOT23-5

Connections:
3.3V: C4.1, C5.2, D3.A, J1.2, J3.2, J4.2, J6.3, JP1.2, JP2.2, R3.2, U1.7 (VDD_USB), U1.23 (VCC), U2.5 (OUT)
5V: C2.1, D4.5, J5.VBUS1 (VBUS), J5.VBUS2 (VBUS), J6.2, U2.1 (IN), U2.3 (EN)
!RESET: J2.2, U1.8 (!RST)
ANT_VCC: C3.1, FB1.2, R15.1
D+: D4.4, R1.1
D-: D4.6, R2.1
D_SEL: JP4.2, U1.2 (D_SEL)
EXT_INT: J2.4, U1.4 (EXT_INT)
GND: BT1.-, C1.2, C2.2, C3.2, C4.2, C5.1, D1.C, D2.C, D4.2, J1.1, J3.1, J4.1, J5.GND, J5.GND2 (GND), J6.1, J7.1 (GND), J7.2 (GND), JP4.1, R3.1, R12.1, R13.1, U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND), U2.2 (GND)
GPS_ANT1: FB1.1, J7.FEED (SIGNAL), U1.11 (RF_IN)
unnamed: JP2.1, R5.2
unnamed: D2.A, R6.1
unnamed: R8.1, U1.18 (SDA/SPI_!CS!)
unnamed: JP3.1, R6.2
unnamed: JP1.1, R7.2
unnamed: D3.C, R14.2
unnamed: J5.B5 (CC2), R12.2
unnamed: JP1.3, R4.2
unnamed: J5.A5 (CC1), R13.2
unnamed: D1.A, R5.1
unnamed: R1.2, U1.6 (USB_D+)
unnamed: R2.2, U1.5 (USB_D-)
unnamed: R9.1, U1.19 (SCL/SPI_CLK)
unnamed: R10.1, U1.20 (TX/SPI_MISO)
unnamed: R11.1, U1.21 (RX/SPI_MOSI)
PPS: J2.1, JP3.2, U1.3 (TIMEPULSE)
RXI/MOSI: J6.5, R11.2
SCL/SCK: J1.4, J3.4, J4.4, J6.7, R4.1, R9.2
SDA/!CS: J1.3, J3.3, J4.3, J6.4, R7.1, R8.2
SHIELD: J5.SHLD1 (SHLD), J5.SHLD2 (SHLD), J5.SHLD3 (SHLD), J5.SHLD4 (SHLD)
TP2/!SAFE: J2.3, U1.1 (!SAFEBOOT!)
TXO/MISO: J6.6, R10.2
USB_D+: D4.3, J5.A6 (D+), J5.B6 (D+)
USB_D-: D4.1, J5.A7 (D-), J5.B7 (D-)
VDD: R15.2, U1.9 (VCC_RF)
V_BATT: BT1.+, C1.1, R14.1, U1.22 (V_BKCP)

Notes on the sheet:
V10
7-bit unshifted I2C address: 0x42
Cut jumper to remove I2C pullups from bus
Cut jumpers to disable LEDs
Close jumper to enable SPI
Elias Santistevan
Headers
LEDs and Jumpers
Hot Start Battery
GPS: u-Blox NEO-M8U
u.FL Antenna
USB Connector - Power
Based on design by: Nathan Seidle
VCC Range: 2.7 - 3.6V
I2C

Board: 2 copper layers, 40.2 x 32.6 mm, 98 parts (31 on the bottom side), 36 nets.

Other parts of the board:
U$1, U$4: SDA-[)
U$2: INT1
U$3, U$5: SCL-[)
U$6, U$7, U$60, U$61: 3V3-04
U$8, U$9, U$62, U$63: GND-04
U$10: I_SUPER2_C-()-03
U$11: SPI1
U$12, U$52: PPS0
U$13, U$16: X1
U$14: QWIIC_4MM
U$15, U$34: NEO#M8U0
U$17: PWR1
U$18: PWR-()-03
U$19, U$20: 5V
U$21, U$27: Y2
U$22: U#BLOX3
U$23, U$24: CS#-<]
U$25: ANT0
U$26, U$31: RX#MOSI3
U$28, U$30: Z0
U$29, U$37: TX#MISO1
U$32: INT0
U$33: SFE_LOGO_FLAME_.1
U$35, U$36: #RST3
U$38, U$41: SCK-(]-04
U$39, U$40: #SAFE1
U$43, U$44: PPS5

## EAGLE design Hardware/SparkFun NEO-M8T.brd

Parts:
B1: 6.8MM_COIN_CELL; ML414H_IV01E
C1: 47pF; 0603
C3, C4, C6: 1.0uF; 0603
C5: 0.1uF; 0603
D2: 0.5A/40V/420mV; SOD-323
D3: PRTR5V0U2F; SOT886
FB1: 30Ω/1.8A; 0603
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1: CONN_07NO_SILK; 1X07_NO_SILK
J2, J4: Qwiic Right Angle; JST04_1MM_RA
J3: USB_C2-LAYER; USB-C-16P
J5: CONN_041X04_NO_SILK; 1X04_NO_SILK
J13: U.FL
JP5: JUMPER-SMT_3_2-NC_TRACE_SILK; SMT-JUMPER_3_2-NC_TRACE_SILK
JP15: CONN_05NO_SILK; 1X05_NO_SILK
JP21, JP61, JP71, JP81: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
JP31, JP41, JP91, JP101: STAND-OFF
LED1: BLUE; LED-0603
LED2: RED; LED-0603
LOGO1: OSHW-LOGOMINI; OSHW-LOGO-MINI
LOGO2: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
PPS: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
PWR\: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
R1, R5, R11: 1k; 0603
R2, R3, R4, R6: 33; 0603
R7, R8: 2.2k; 0603
R9, R10: 27; 0603
R12, R13: 5.1k; 0603
R14: 10; 0603
R15: 100k; 0603
SPI: JUMPER-SMT_2_NO_SILK; SMT-JUMPER_2_NO_SILK
U1: U-BLOX_NEO-M8T; NEO-M9N/M8T
U2: 3.3V; SOT23-5

Connections:
3.3V: C4.1, C5.2, D2.A, J1.3, J2.2, J4.2, J5.2, JP5.2, PWR\.2, R15.2, U1.7 (VDD_USB), U1.23 (VCC), U2.5 (OUT)
5V: C6.1, D3.5, J1.2, J3.VBUS1 (VBUS), J3.VBUS2 (VBUS), U2.1 (IN), U2.3 (EN)
!RESET: JP15.4, U1.8 (!RST)
ANT_VCC: C1.1, FB1.2, R14.1
BACKUP: B1.+, C3.1, R5.1, U1.22 (V_BKCP)
D+: D3.4, R9.1
D-: D3.6, R10.1
D_SEL: SPI.2, U1.2 (D_SEL)
GND: B1.-, C1.2, C3.2, C4.2, C5.1, C6.2, D3.2, J1.1, J2.1, J3.GND, J3.GND2 (GND), J4.1, J5.1, J13.1 (GND), J13.2 (GND), LED1.C, LED2.C, R12.1, R13.1, R15.1, SPI.1, U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND), U2.2 (GND)
GPS_ANT1: FB1.1, J13.FEED (SIGNAL), U1.11 (RF_IN)
INT0: JP15.2, U1.4 (EXTINT0)
INT1: JP15.1, U1.15 (EXTINT1)
unnamed: PWR\.1, R1.2
unnamed: LED1.A, R11.1
unnamed: R2.1, U1.18 (SDA/SPI_!CS!)
unnamed: PPS.1, R11.2
unnamed: JP5.1, R8.2
unnamed: D2.C, R5.2
unnamed: J3.B5 (CC2), R12.2
unnamed: JP5.3, R7.2
unnamed: J3.A5 (CC1), R13.2
unnamed: LED2.A, R1.1
unnamed: R9.2, U1.6 (USB_D+)
unnamed: R10.2, U1.5 (USB_D-)
unnamed: R4.1, U1.19 (SCL/SPI_CLK)
PPS: JP15.5, PPS.2, U1.3 (TIMEPULSE)
RXI/MOSI: J1.5, R6.2
RXLV: R6.1, U1.21 (RX/SPI_MOSI)
SCL/SCK: J1.7, J2.4, J4.4, J5.4, R4.2, R7.1
SDA/!CS: J1.4, J2.3, J4.3, J5.3, R2.2, R8.1
SHLD: J3.SHLD1 (SHLD), J3.SHLD2 (SHLD), J3.SHLD3 (SHLD), J3.SHLD4 (SHLD), J3.SHLD5 (SHLD), J3.SHLD6 (SHLD), J3.SHLD7 (SHLD), J3.SHLD8 (SHLD)
TP2/!SAFE: JP15.3, U1.1 (TP2/!SAFEBOOT!)
TXLV: R3.1, U1.20 (TX/SPI_MISO)
TXO/MISO: J1.6, R3.2
USB_D+: D3.3, J3.A6 (D+), J3.B6 (D+)
USB_D-: D3.1, J3.A7 (D-), J3.B7 (D-)
VCC_RF: R14.2, U1.9 (VCC_RF)

Notes on the sheet:
V10
7-bit unshifted I2C address: 0x42
Cut jumper to remove I2C pullups from bus
Cut jumpers to disable LED
Close jumper to enable SPI
CI160808-33NJ
Elias Santistevan
Headers
LEDs and Jumpers
Hot Start Battery
GPS: u-Blox NEO-M9N
u.FL Antenna
USB Connector - Power
Based on design by: Nathan Seidle
VCC Range: 2.7 - 3.3V

Board: 2 copper layers, 40.6 x 33.0 mm, 92 parts (29 on the bottom side), 37 nets.

Other parts of the board:
U$1, U$4: SDA-[)
U$3, U$5: SCL-[)
U$6, U$7, U$60, U$61: 3V3-04
U$8, U$9, U$62, U$63: GND-04
U$10: I_SUPER2_C-()-03
U$11: SPI1
U$12, U$52: PPS0
U$13, U$14: QWIIC_4MM
U$15, U$16: INT8
U$17: PWR1
U$18: PWR-()-03
U$19, U$20: 5V
U$21: NEO_GPS_BOARD_SILK_FINAL#03#JPG
U$22: U#BLOX3
U$23, U$24: CS#-<]
U$25: ANT0
U$26: RX#MOSI2
U$31: RX#MOSI3
U$33: SFE_LOGO_FLAME_.1
U$34: TX#MISO0
U$35, U$36: #RST3
U$37: TX#MISO1
U$38, U$41: SCK-(]-04
U$39, U$40: #SAFE1
U$43, U$44: PPS5

## EAGLE design Production/SparkFun NEO-M8U-Panel.brd

Board: 2 copper layers, 95.2 x 133.9 mm, 587 parts (188 on the bottom side), 216 nets.

Parts:
BT1, BT2, BT3, BT4, BT5, BT6: 6.8MM_COIN_CELL; ML414H_IV01E
C1, C2, C4, C6, C7, C9, C11, C12, C14, C16, C17, C19, C21, C22, C24, C26, C27, C29: 1.0uF; 0603
C3, C10, C15, C20, C25, C30: 47pF; 0603
C5, C8, C13, C18, C23, C28: 0.1uF; 0603
D1, D7, D11, D15, D19, D23: RED; LED-0603
D2, D5, D9, D13, D17, D21: BLUE; LED-0603
D3, D6, D10, D14, D18, D22: 0.5A/40V/420mV; SOD-323
D4, D8, D12, D16, D20, D24: PRTR5V0U2F; SOT886
E$1, E$2, E$3, E$4: FIDUCIAL-1X2
E$5: FIDUCIAL-1.5X3
FB1, FB2, FB3, FB4, FB5, FB6: 30Ω/1.8A; 0603
J1, J2, J12, J14, J19, J21, J26, J28, J33, J35, J40, J42: 1X04_NO_SILK
J3, J4, J8, J9, J15, J16, J22, J23, J29, J30, J36, J37: Qwiic Right Angle; JST04_1MM_RA
J5, J13, J20, J27, J34, J41: USB-C-16P-2LAYER-PADS
J6, J11, J18, J25, J32, J39: 1X07_NO_SILK
J7, J10, J17, J24, J31, J38: U.FL
JP1, JP17, JP29, JP41, JP53, JP65: JUMPER-SMT_3_2-NC_TRACE_SILK; SMT-JUMPER_3_2-NC_TRACE_SILK
JP2, JP3, JP18, JP24, JP30, JP36, JP42, JP48, JP54, JP60, JP66, JP72: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
JP4, JP23, JP35, JP47, JP59, JP71: JUMPER-SMT_2_NO_SILK; SMT-JUMPER_2_NO_SILK
JP5, JP6, JP7, JP8, JP15, JP16, JP19, JP20, JP27, JP28, JP31, JP32, JP39, JP40, JP43, JP44, JP51, JP52, JP55, JP56, JP63, JP64, JP67, JP68: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
JP9, JP10, JP11, JP12, JP13, JP14, JP21, JP22, JP25, JP26, JP33, JP34, JP37, JP38, JP45, JP46, JP49, JP50, JP57, JP58, JP61, JP62, JP69, JP70: STAND-OFF
LOGO1, LOGO3, LOGO5, LOGO7, LOGO9, LOGO11: OSHW-LOGOMINI; OSHW-LOGO-MINI
LOGO2, LOGO4, LOGO6, LOGO8, LOGO10, LOGO12: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
R1, R2, R25, R26, R40, R41, R55, R56, R70, R71, R85, R86: 27; 0603
R3, R28, R43, R58, R73, R88: 100k; 0603
R4, R7, R18, R19, R33, R34, R48, R49, R63, R64, R78, R79: 2.2k; 0603
R5, R6, R14, R20, R21, R24, R35, R36, R39, R50, R51, R54, R65, R66, R69, R80, R81, R84: 1k; 0603
R8, R9, R10, R11, R16, R17, R22, R23, R31, R32, R37, R38, R46, R47, R52, R53, R61, R62, R67, R68, R76, R77, R82, R83: 33; 0603
R12, R13, R29, R30, R44, R45, R59, R60, R74, R75, R89, R90: 5.1k; 0603
R15, R27, R42, R57, R72, R87: 10; 0603
U1, U4, U6, U8, U10, U12: U-BLOX_MEO-M8U; NEO-M9N/M8T/M8U
U2, U3, U5, U7, U9, U11: 3.3V; SOT23-5
U$1, U$4, U$42, U$46, U$97, U$99, U$145, U$147, U$193, U$195, U$241, U$243: SDA-[)
U$2, U$94, U$142, U$190, U$238, U$286: INT1
U$3, U$5, U$45, U$47, U$98, U$100, U$146, U$148, U$194, U$196, U$242, U$244: SCL-[)
U$6, U$7, U$48, U$49, U$60, U$61, U$66, U$67, U$101, U$102, U$114, U$115, U$149, U$150, U$162, U$163, U$197, U$198, U$210, U$211, U$245, U$246, U$258, U$259: 3V3-04
U$8, U$9, U$50, U$51, U$62, U$63, U$68, U$69, U$103, U$104, U$116, U$117, U$151, U$152, U$164, U$165, U$199, U$200, U$212, U$213, U$247, U$248, U$260, U$261: GND-04
U$10, U$53, U$105, U$153, U$201, U$249: I_SUPER2_C-()-03
U$11, U$80, U$128, U$176, U$224, U$272: SPI1
U$12, U$52, U$65, U$82, U$113, U$130, U$161, U$178, U$209, U$226, U$257, U$274: PPS0
U$13, U$16, U$85, U$91, U$133, U$139, U$181, U$187, U$229, U$235, U$277, U$283: X1
U$14, U$81, U$129, U$177, U$225, U$273: QWIIC_4MM
U$15, U$34, U$90, U$96, U$138, U$144, U$186, U$192, U$234, U$240, U$282, U$288: NEO#M8U0
U$17, U$83, U$131, U$179, U$227, U$275: PWR1
U$18, U$70, U$118, U$166, U$214, U$262: PWR-()-03
U$19, U$20, U$71, U$72, U$119, U$120, U$167, U$168, U$215, U$216, U$263, U$264: 5V
U$21, U$27, U$86, U$92, U$134, U$140, U$182, U$188, U$230, U$236, U$278, U$284: Y2
U$22, U$54, U$106, U$154, U$202, U$250: U#BLOX3
U$23, U$24, U$73, U$74, U$121, U$122, U$169, U$170, U$217, U$218, U$265, U$266: CS#-<]
U$25, U$84, U$132, U$180, U$228, U$276: ANT0
U$26, U$31, U$78, U$88, U$126, U$136, U$174, U$184, U$222, U$232, U$270, U$280: RX#MOSI3
U$28, U$30, U$87, U$93, U$135, U$141, U$183, U$189, U$231, U$237, U$279, U$285: Z0
U$29, U$37, U$79, U$89, U$127, U$137, U$175, U$185, U$223, U$233, U$271, U$281: TX#MISO1
U$32, U$95, U$143, U$191, U$239, U$287: INT0
U$33, U$77, U$125, U$173, U$221, U$269: SFE_LOGO_FLAME_.1
U$35, U$36, U$55, U$56, U$107, U$108, U$155, U$156, U$203, U$204, U$251, U$252: #RST3
U$38, U$41, U$75, U$76, U$123, U$124, U$171, U$172, U$219, U$220, U$267, U$268: SCK-(]-04
U$39, U$40, U$57, U$58, U$109, U$110, U$157, U$158, U$205, U$206, U$253, U$254: #SAFE1
U$43, U$44, U$59, U$64, U$111, U$112, U$159, U$160, U$207, U$208, U$255, U$256: PPS5

Connections:
3.3V: C4.1, C5.2, D3.A, J1.2, J3.2, J4.2, J6.3, JP1.2, JP2.2, R3.2, U1.7, U1.23, U2.5
3.3V1: C7.1, C8.2, D6.A, J8.2, J9.2, J11.3, J12.2, JP17.2, JP24.2, R28.2, U3.5, U4.7, U4.23
3.3V2: C12.1, C13.2, D10.A, J15.2, J16.2, J18.3, J19.2, JP29.2, JP36.2, R43.2, U5.5, U6.7, U6.23
3.3V3: C17.1, C18.2, D14.A, J22.2, J23.2, J25.3, J26.2, JP41.2, JP48.2, R58.2, U7.5, U8.7, U8.23
3.3V4: C22.1, C23.2, D18.A, J29.2, J30.2, J32.3, J33.2, JP53.2, JP60.2, R73.2, U9.5, U10.7, U10.23
3.3V5: C27.1, C28.2, D22.A, J36.2, J37.2, J39.3, J40.2, JP65.2, JP72.2, R88.2, U11.5, U12.7, U12.23
5V: C2.1, D4.5, J5.VBUS1, J5.VBUS2, J6.2, U2.1, U2.3
5V1: C9.1, D8.5, J11.2, J13.VBUS1, J13.VBUS2, U3.1, U3.3
5V2: C14.1, D12.5, J18.2, J20.VBUS1, J20.VBUS2, U5.1, U5.3
5V3: C19.1, D16.5, J25.2, J27.VBUS1, J27.VBUS2, U7.1, U7.3
5V4: C24.1, D20.5, J32.2, J34.VBUS1, J34.VBUS2, U9.1, U9.3
5V5: C29.1, D24.5, J39.2, J41.VBUS1, J41.VBUS2, U11.1, U11.3
!RESET: J2.2, U1.8
!RESET1: J14.2, U4.8
!RESET2: J21.2, U6.8
!RESET3: J28.2, U8.8
!RESET4: J35.2, U10.8
!RESET5: J42.2, U12.8
ANT_VCC: C3.1, FB1.2, R15.1
ANT_VCC1: C10.1, FB2.2, R27.1
ANT_VCC2: C15.1, FB3.2, R42.1
ANT_VCC3: C20.1, FB4.2, R57.1
ANT_VCC4: C25.1, FB5.2, R72.1
ANT_VCC5: C30.1, FB6.2, R87.1
D+: D4.4, R1.1
D+1: D8.4, R25.1
D+2: D12.4, R40.1
D+3: D16.4, R55.1
D+4: D20.4, R70.1
D+5: D24.4, R85.1
D-: D4.6, R2.1
D-1: D8.6, R26.1
D-2: D12.6, R41.1
D-3: D16.6, R56.1
D-4: D20.6, R71.1
D-5: D24.6, R86.1
D_SEL: JP4.2, U1.2
D_SEL1: JP23.2, U4.2
D_SEL2: JP35.2, U6.2
D_SEL3: JP47.2, U8.2
D_SEL4: JP59.2, U10.2
D_SEL5: JP71.2, U12.2
EXT_INT: J2.4, U1.4
EXT_INT1: J14.4, U4.4
EXT_INT2: J21.4, U6.4
EXT_INT3: J28.4, U8.4
EXT_INT4: J35.4, U10.4
EXT_INT5: J42.4, U12.4
GND: BT1.-, C1.2, C2.2, C3.2, C4.2, C5.1, D1.C, D2.C, D4.2, J1.1, J3.1, J4.1, J5.GND, J5.GND2, J6.1, J7.1, J7.2, JP4.1, R3.1, R12.1, R13.1, U1.10, U1.12, U1.13, U1.24, U2.2
GND1: BT2.-, C6.2, C7.2, C8.1, C9.2, C10.2, D5.C, D7.C, D8.2, J8.1, J9.1, J10.1, J10.2, J11.1, J12.1, J13.GND, J13.GND2, JP23.1, R28.1, R29.1, R30.1, U3.2, U4.10, U4.12, U4.13, U4.24
GND2: BT3.-, C11.2, C12.2, C13.1, C14.2, C15.2, D9.C, D11.C, D12.2, J15.1, J16.1, J17.1, J17.2, J18.1, J19.1, J20.GND, J20.GND2, JP35.1, R43.1, R44.1, R45.1, U5.2, U6.10, U6.12, U6.13, U6.24
GND3: BT4.-, C16.2, C17.2, C18.1, C19.2, C20.2, D13.C, D15.C, D16.2, J22.1, J23.1, J24.1, J24.2, J25.1, J26.1, J27.GND, J27.GND2, JP47.1, R58.1, R59.1, R60.1, U7.2, U8.10, U8.12, U8.13, U8.24
GND4: BT5.-, C21.2, C22.2, C23.1, C24.2, C25.2, D17.C, D19.C, D20.2, J29.1, J30.1, J31.1, J31.2, J32.1, J33.1, J34.GND, J34.GND2, JP59.1, R73.1, R74.1, R75.1, U9.2, U10.10, U10.12, U10.13, U10.24
GND5: BT6.-, C26.2, C27.2, C28.1, C29.2, C30.2, D21.C, D23.C, D24.2, J36.1, J37.1, J38.1, J38.2, J39.1, J40.1, J41.GND, J41.GND2, JP71.1, R88.1, R89.1, R90.1, U11.2, U12.10, U12.12, U12.13, U12.24
GPS_ANT1: FB1.1, J7.FEED, U1.11
GPS_ANT2: FB2.1, J10.FEED, U4.11
GPS_ANT3: FB3.1, J17.FEED, U6.11
GPS_ANT4: FB4.1, J24.FEED, U8.11
GPS_ANT5: FB5.1, J31.FEED, U10.11
GPS_ANT6: FB6.1, J38.FEED, U12.11
unnamed: JP2.1, R5.2
unnamed: D2.A, R6.1
unnamed: R8.1, U1.18
unnamed: JP3.1, R6.2
unnamed: JP1.1, R7.2
unnamed: D3.C, R14.2
unnamed: J5.B5, R12.2
unnamed: JP1.3, R4.2
unnamed: J5.A5, R13.2
unnamed: D1.A, R5.1
unnamed: R1.2, U1.6
unnamed: R2.2, U1.5
unnamed: R9.1, U1.19
unnamed: JP17.1, R19.2
unnamed: R10.1, U1.20
unnamed: R11.1, U1.21
unnamed: JP17.3, R18.2
unnamed: D5.A, R21.1
unnamed: JP18.1, R21.2
unnamed: D6.C, R20.2
unnamed: D7.A, R24.1
unnamed: R25.2, U4.6
unnamed: R26.2, U4.5
unnamed: JP24.1, R24.2
unnamed: J13.B5, R29.2
unnamed: J13.A5, R30.2
unnamed: R22.1, U4.18
unnamed: R23.1, U4.19
unnamed: R16.1, U4.20
unnamed: R17.1, U4.21
unnamed: JP29.1, R34.2
unnamed: JP29.3, R33.2
unnamed: D9.A, R36.1
unnamed: JP30.1, R36.2
unnamed: D10.C, R35.2
unnamed: D11.A, R39.1
unnamed: R40.2, U6.6
unnamed: R41.2, U6.5
unnamed: JP36.1, R39.2
unnamed: J20.B5, R44.2
unnamed: J20.A5, R45.2
unnamed: R37.1, U6.18
unnamed: R38.1, U6.19
unnamed: R31.1, U6.20
unnamed: R32.1, U6.21
unnamed: JP41.1, R49.2
unnamed: JP41.3, R48.2
unnamed: D13.A, R51.1
unnamed: JP42.1, R51.2
unnamed: D14.C, R50.2
unnamed: D15.A, R54.1
unnamed: R55.2, U8.6
unnamed: R56.2, U8.5
unnamed: JP48.1, R54.2
unnamed: J27.B5, R59.2
unnamed: J27.A5, R60.2
unnamed: R52.1, U8.18
unnamed: R53.1, U8.19
unnamed: R46.1, U8.20
unnamed: R47.1, U8.21
unnamed: JP53.1, R64.2
unnamed: JP53.3, R63.2
unnamed: D17.A, R66.1
unnamed: JP54.1, R66.2
unnamed: D18.C, R65.2
unnamed: D19.A, R69.1
unnamed: R70.2, U10.6
unnamed: R71.2, U10.5
unnamed: JP60.1, R69.2
unnamed: J34.B5, R74.2
unnamed: J34.A5, R75.2
unnamed: R67.1, U10.18
unnamed: R68.1, U10.19
unnamed: R61.1, U10.20
unnamed: R62.1, U10.21
unnamed: JP65.1, R79.2
unnamed: JP65.3, R78.2
unnamed: D21.A, R81.1
unnamed: JP66.1, R81.2
unnamed: D22.C, R80.2
unnamed: D23.A, R84.1
unnamed: R85.2, U12.6
unnamed: R86.2, U12.5
unnamed: JP72.1, R84.2
unnamed: J41.B5, R89.2
unnamed: J41.A5, R90.2
unnamed: R82.1, U12.18
unnamed: R83.1, U12.19
unnamed: R76.1, U12.20
unnamed: R77.1, U12.21
PPS: J2.1, JP3.2, U1.3
PPS1: J14.1, JP18.2, U4.3
PPS2: J21.1, JP30.2, U6.3
PPS3: J28.1, JP42.2, U8.3
PPS4: J35.1, JP54.2, U10.3
PPS5: J42.1, JP66.2, U12.3
RXI/MOSI: J6.5, R11.2
RXI/MOSI1: J11.5, R17.2
RXI/MOSI2: J18.5, R32.2
RXI/MOSI3: J25.5, R47.2
RXI/MOSI4: J32.5, R62.2
RXI/MOSI5: J39.5, R77.2
SCL/SCK: J1.4, J3.4, J4.4, J6.7, R4.1, R9.2
SCL/SCK1: J8.4, J9.4, J11.7, J12.4, R18.1, R23.2
SCL/SCK2: J15.4, J16.4, J18.7, J19.4, R33.1, R38.2
SCL/SCK3: J22.4, J23.4, J25.7, J26.4, R48.1, R53.2
SCL/SCK4: J29.4, J30.4, J32.7, J33.4, R63.1, R68.2
SCL/SCK5: J36.4, J37.4, J39.7, J40.4, R78.1, R83.2
SDA/!CS: J1.3, J3.3, J4.3, J6.4, R7.1, R8.2
SDA/!CS1: J8.3, J9.3, J11.4, J12.3, R19.1, R22.2
SDA/!CS2: J15.3, J16.3, J18.4, J19.3, R34.1, R37.2
SDA/!CS3: J22.3, J23.3, J25.4, J26.3, R49.1, R52.2
SDA/!CS4: J29.3, J30.3, J32.4, J33.3, R64.1, R67.2
SDA/!CS5: J36.3, J37.3, J39.4, J40.3, R79.1, R82.2
SHIELD: J5.SHLD1, J5.SHLD2, J5.SHLD3, J5.SHLD4
SHIELD1: J13.SHLD1, J13.SHLD2, J13.SHLD3, J13.SHLD4
SHIELD2: J20.SHLD1, J20.SHLD2, J20.SHLD3, J20.SHLD4
SHIELD3: J27.SHLD1, J27.SHLD2, J27.SHLD3, J27.SHLD4
SHIELD4: J34.SHLD1, J34.SHLD2, J34.SHLD3, J34.SHLD4
SHIELD5: J41.SHLD1, J41.SHLD2, J41.SHLD3, J41.SHLD4
TP2/!SAFE: J2.3, U1.1
TP2/!SAFE1: J14.3, U4.1
TP2/!SAFE2: J21.3, U6.1
TP2/!SAFE3: J28.3, U8.1
TP2/!SAFE4: J35.3, U10.1
TP2/!SAFE5: J42.3, U12.1
TXO/MISO: J6.6, R10.2
TXO/MISO1: J11.6, R16.2
TXO/MISO2: J18.6, R31.2
TXO/MISO3: J25.6, R46.2
TXO/MISO4: J32.6, R61.2
TXO/MISO5: J39.6, R76.2
USB_D+: D4.3, J5.A6, J5.B6
USB_D+1: D8.3, J13.A6, J13.B6
USB_D+2: D12.3, J20.A6, J20.B6
USB_D+3: D16.3, J27.A6, J27.B6
USB_D+4: D20.3, J34.A6, J34.B6
USB_D+5: D24.3, J41.A6, J41.B6
USB_D-: D4.1, J5.A7, J5.B7
USB_D-1: D8.1, J13.A7, J13.B7
USB_D-2: D12.1, J20.A7, J20.B7
USB_D-3: D16.1, J27.A7, J27.B7
USB_D-4: D20.1, J34.A7, J34.B7
USB_D-5: D24.1, J41.A7, J41.B7
VDD: R15.2, U1.9
VDD1: R27.2, U4.9
VDD2: R42.2, U6.9
VDD3: R57.2, U8.9
VDD4: R72.2, U10.9
VDD5: R87.2, U12.9
V_BATT: BT1.+, C1.1, R14.1, U1.22
V_BATT1: BT2.+, C6.1, R20.1, U4.22
V_BATT2: BT3.+, C11.1, R35.1, U6.22
V_BATT3: BT4.+, C16.1, R50.1, U8.22
V_BATT4: BT5.+, C21.1, R65.1, U10.22
V_BATT5: BT6.+, C26.1, R80.1, U12.22

## Commit log

2020-01-28 Adds datasheet
2020-01-28 Adds supporting files and hardware template
2020-01-29 Some updates to the design (heh)
2020-01-30 Removes 10k from board
2020-01-31 This is now the M8U repo not the M8T
2020-02-03 Updates design with the M8U module
2020-02-03 Updates the ground and shield pour
2020-02-04 Updates design to improve ground pout
2020-02-04 Adds silk for the orientation of the IMU
2020-02-04 Moves a single (yeah) via
2020-02-05 Moves some silk around - resizes some .015 drill hits to .012
2020-02-05 Moves battery circuit around for better aesthetic (heh), adjusts various labels
2020-02-05 Updates old schematic artifacts, replace power lables with their proper symbols
2020-02-10 Adds silk - fixes some DRC errors
2020-02-10 Adds interrupt silk
2020-02-10 Adds gerbers for prototype
2020-03-23 Rolls version to v10 and updates all of the parts' packages
2020-03-24 Updates the README
2020-03-24 Removes old gerbers and buzzard labels, fixes some minor board inconsistencies
2020-03-24 Updates some silk, removes wire stubs
2020-03-25 Adjusts some wonky trace widths, moves some traces for better pour
2020-03-25 Fixes more trace widths
2020-03-25 Adds panel for production
2020-03-26 Update README.md
    Link product page and tutorial. =)
2022-04-07 Fixes "u-blox" typo in schematic

Notices in the files:
parts and their libraries:
SparkFun-Resistors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
